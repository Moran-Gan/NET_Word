# Keil uVision project NET-DK-L1011.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: NET-DK-L1001-DB +hex
  AfterMake: .\Objects\1.bat
  c flags: Optimize=4 SizeSpeed=1
  c define: Quectel_tx_WiFi,Brand_ENERGY
  c include: .\User;.\User\HeadFiles;.\FWLib\Dwin_Lib\inc;.\FWLib\Dwin_Lib\src;.\Drivers\tuya_wifi;.\Apps
  link misc: REMOVEUNUSED
  group User
    ./: STARTUP_M5.A51
    ./User/: main.c Dwin_it.c user_global.c user_key_driver.c user_Task_sched.c user_special_process.c user_modbus_process.c user_system_process.c user_OnlineTest_process.c temp.c DHT83.c
  group Apps
    ./Apps/: mcu_api.c protocol.c system.c
  group Drivers
    ./Drivers/tuya_wifi/: mcu_api.c protocol.c system.c
  group FWLib
    ./FWLib/Dwin_Lib/src/: Dwin_8130.c Dwin_ad.c Dwin_flash.c Dwin_IIC.c Dwin_int.c Dwin_time2.c Dwin_Uart2.c Dwin_Uart3.c Dwin_Uart4.c Dwin_Uart5.c Dwin_wdt.c Dwin_wirte_value.c
